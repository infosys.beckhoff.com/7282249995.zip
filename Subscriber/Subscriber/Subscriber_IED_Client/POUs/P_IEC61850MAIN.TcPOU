PROGRAM P_IEC61850MAIN
VAR
END_VAR

fbIEDGse();

END_PROGRAM
